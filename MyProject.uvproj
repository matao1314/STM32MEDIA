# Keil uVision project MyProject.uvproj, settings and files
target MyProject (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MyProject +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS\startup;.\CMSIS;.\FWLIB\inc;.\HARDWARE;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LCD;.\HARDWARE\SPI;.\HARDWARE\SD;.\HARDWARE\FLASH;.\HARDWARE\MALLOC;.\HARDWARE\LED;.\HARDWARE\VS10XX;.\APP\mp3palyer;.\FATFS\exfuns;.\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./USER/: stm32f10x_it.c main.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/FLASH/: flash.c
    ./HARDWARE/MALLOC/: malloc.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/VS10XX/: VS10XX.c
    ./HARDWARE/SD/: sdcard.c sd_fs_app.c
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group DOC
    ./: DOC.txt
  group APP
    ./APP/mp3palyer/: mp3player.c
